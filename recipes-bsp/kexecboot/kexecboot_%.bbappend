FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

require kexecboot-handhelds.inc
