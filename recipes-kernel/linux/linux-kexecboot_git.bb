require linux-kexecboot.inc
require linux-git.inc

PR = "${INC_PR}.0"
