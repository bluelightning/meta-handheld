require linux-kexecboot.inc
require linux-${PV}.inc

PR = "${INC_PR}.4"
S = "${WORKDIR}/linux-${PV}"
